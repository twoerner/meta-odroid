LINUX_VERSION ?= "4.17-rc5"
SRCREV ?= "67b8d5c7081221efa252e111cd52532ec6d4266f"

require linux-mainline.inc

COMPATIBLE_MACHINE = "(odroid-c1|odroid-c2|odroid-xu3|odroid-xu4|odroid-xu3-lite|odroid-hc1)"
